# Keil uVision project PY32F002A.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: PY32F002Ax5 Puya
  pack: Puya.PY32F0xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00000C00) IROM(0x08000000,0x00005000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: PY32F002A
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,PY32F002Ax5
  c include: ..\Core\Inc;..\Bsp;.\RTE\Drivers\PY32F002Ax5
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x5000
  memory RVCT9: RAM 0x20000000 size 0xc00
  group Application/Core
    ../Core/Src/: main.c py32f0xx_it.c usart.c
software components: CMSIS:CORE 4.3.0, Drivers:PY32F0xx HAL Driver 1.1.5, Device:Startup 1.0.0
